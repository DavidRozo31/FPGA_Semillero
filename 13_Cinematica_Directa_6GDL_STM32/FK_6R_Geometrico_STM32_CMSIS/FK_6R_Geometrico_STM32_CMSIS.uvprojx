# Keil uVision project FK_6R_Geometrico_STM32_CMSIS.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: FK_6R_Geometrico_STM32_CMSIS +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: FK_6R_Geometrico_STM32_CMSIS.cpp
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:Startup 1.2.5
